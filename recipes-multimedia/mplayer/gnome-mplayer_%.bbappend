PNBLACKLIST[gnome-mplayer] = ""
